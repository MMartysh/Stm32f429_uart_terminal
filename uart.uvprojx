# Keil uVision project uart.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group :STM32CubeMX:Common Sources
    ./: uart.c uart.h
    ./RTE/Device/STM32F429ZITx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F429ZITx/STCubeGenerated/Inc/: stm32f4xx_it.h
software components: CMSIS:CORE 5.3.0, Board Support:Common 1.0.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:USART 2.12, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:UART 1.7.6, Device:STM32Cube HAL:USART 1.7.6, Device:Startup 2.6.3
